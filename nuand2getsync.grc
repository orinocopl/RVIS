options:
  parameters:
    generate_options: no_gui
    id: nuand2sync
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: parameter
  parameters:
    label: Bandwidth LP
    type: eng_float
    value: '2000000'
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    buffers: '4096'
    buflen: '32768'
    bw: bandwidth
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: 0ab3220d828942b4a34ec09db0c8970c
    feature: default
    fpga_image: ''
    fpga_reload: 'False'
    freq: tuning
    gain0: gain4
    gain1: gain4
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '0'
    if_gain1: '0'
    in_clk: EXTERNAL
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '2'
    out_clk: 'False'
    ref_clk: '38400000'
    sample_format: 16bit
    sample_rate: sps
    sampling: internal
    show_pmic: 'False'
    smb: 38.4e6
    tamer: internal
    trigger0: 'True'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: slave
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'False'
    verbosity: verbose
    xb200: none
  states: {}
- name: bladeRF_source_0_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    buffers: '4096'
    buflen: '32768'
    bw: bandwidth
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: f3e9a1d78d7d4041afd8dbd9ab1a76e4
    feature: default
    fpga_image: ''
    fpga_reload: 'False'
    freq: tuning
    gain0: gain4
    gain1: gain4
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '0'
    if_gain1: '0'
    in_clk: EXTERNAL
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '2'
    out_clk: 'False'
    ref_clk: '38400000'
    sample_format: 16bit
    sample_rate: sps
    sampling: internal
    show_pmic: 'False'
    smb: 38.4e6
    tamer: internal
    trigger0: 'True'
    trigger1: 'False'
    trigger_role0: slave
    trigger_role1: slave
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'False'
    verbosity: verbose
    xb200: none
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_short_0_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_short_0_0_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_short_0_1
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/nuand0.bin
    type: short
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/nuand1.bin
    type: short
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/nuand3.bin
    type: short
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/nuand2.bin
    type: short
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: nosamples
    type: complex
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: nosamples
    type: complex
  states: {}
- name: blocks_head_0_0_0
  id: blocks_head
  parameters:
    num_items: nosamples
    type: complex
  states: {}
- name: blocks_head_0_1
  id: blocks_head
  parameters:
    num_items: nosamples
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '32767'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '32767'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '32767'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '32767'
    type: complex
  states: {}
- name: gain4
  id: parameter
  parameters:
    label: Common Gain
    type: eng_float
    value: '-1'
  states: {}
- name: nosamples
  id: parameter
  parameters:
    label: No.samples
    type: intx
    value: '50000000'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: '10000000'
  states: {}
- name: tuning
  id: parameter
  parameters:
    label: Frequency
    type: intx
    value: '868000000'
  states: {}

connections:
- [bladeRF_source_0, '0', blocks_head_0, '0']
- [bladeRF_source_0, '1', blocks_head_0_0, '0']
- [bladeRF_source_0_0, '0', blocks_head_0_1, '0']
- [bladeRF_source_0_0, '1', blocks_head_0_0_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_interleaved_short_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_complex_to_interleaved_short_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_complex_to_interleaved_short_0_1, '0', blocks_file_sink_0_1, '0']
- [blocks_head_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_head_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_head_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_head_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_complex_to_interleaved_short_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_complex_to_interleaved_short_0_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_complex_to_interleaved_short_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
